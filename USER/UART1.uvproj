# Keil uVision project UART1.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: UART1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ../CH/: ADC.c PCA.c delay.c main.c USART1.C data_transfer.C pid.c timer.c
